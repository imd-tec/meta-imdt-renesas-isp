# meta-rz-isp limits this recipe to rzv2h-evk
COMPATIBLE_MACHINE:imdt-v2n-sbc = "imdt-v2n-sbc"
