FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://isp_overlays.cfg"